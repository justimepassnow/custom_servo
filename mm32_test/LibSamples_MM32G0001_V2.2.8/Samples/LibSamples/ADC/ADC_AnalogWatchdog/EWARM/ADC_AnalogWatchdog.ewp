# IAR project ADC_AnalogWatchdog.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32G0001A6TC MindMotion MM32G0001A6TC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\Device\CMSIS\Core\Include; ..\..\..\..\..\Device\MM32G0001\Include; ..\..\..\..\..\Device\MM32G0001\HAL_Lib\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC_AnalogWatchdog.srec
  ILINK.IlinkOutputFile: ADC_AnalogWatchdog.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../: adc_analogwatchdog.c main.c mm32g0001_it.c platform.c
  group DOC
    ../: readme.txt
  group HAL_LIB
    ../../../../../Device/MM32G0001/HAL_Lib/src/: hal_adc.c hal_crc.c hal_dbg.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_syscfg.c hal_tim.c hal_uid.c hal_usart.c
  group STARTUP
    ../../../../../Device/MM32G0001/Source/IAR_StartAsm/: startup_mm32g0001_iar.s
    ../../../../../Device/MM32G0001/Source/: system_mm32g0001.c
