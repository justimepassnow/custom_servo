<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\USART_Synchronous_Polling.ewp</path>
    </project>
    <batchBuild />
</workspace>
