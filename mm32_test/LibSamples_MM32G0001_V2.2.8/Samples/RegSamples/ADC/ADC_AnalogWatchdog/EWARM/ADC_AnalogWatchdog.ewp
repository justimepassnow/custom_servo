# IAR project ADC_AnalogWatchdog.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32G0001A1TC MindMotion MM32G0001A1TC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\Device\CMSIS\Core\Include; ..\..\..\..\..\Device\MM32G0001\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC_AnalogWatchdog.srec
  ILINK.IlinkOutputFile: ADC_AnalogWatchdog.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../: adc_analogwatchdog.c main.c mm32g0001_it.c platform.c
  group DOC
    ../: readme.txt
  group STARTUP
    ../../../../../Device/MM32G0001/Source/IAR_StartAsm/: startup_mm32g0001_iar.s
    ../../../../../Device/MM32G0001/Source/: system_mm32g0001.c
