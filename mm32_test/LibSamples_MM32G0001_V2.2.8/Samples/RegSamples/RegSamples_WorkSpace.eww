<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\ADC\ADC_AnalogWatchdog\EWARM\ADC_AnalogWatchdog.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\ADC\ADC_AnyChannel_ContinuousScan_Interrupt\EWARM\ADC_AnyChannel_ContinuousScan_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\ADC\ADC_AnyChannel_ContinuousScan_Polling\EWARM\ADC_AnyChannel_ContinuousScan_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\ADC\ADC_AnyChannel_OneCycleScan_Interrupt\EWARM\ADC_AnyChannel_OneCycleScan_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\ADC\ADC_AnyChannel_OneCycleScan_Polling\EWARM\ADC_AnyChannel_OneCycleScan_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\ADC\ADC_AnyChannel_SingleConversion_Interrupt\EWARM\ADC_AnyChannel_SingleConversion_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\ADC\ADC_AnyChannel_SingleConversion_Polling\EWARM\ADC_AnyChannel_SingleConversion_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\ADC\ADC_EXTI_Trigger\EWARM\ADC_EXTI_Trigger.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\ADC\ADC_InternalVoltageSensor\EWARM\ADC_InternalVoltageSensor.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\ADC\ADC_TIM_CC_Trigger\EWARM\ADC_TIM_CC_Trigger.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\ADC\ADC_TIM_TRGO_Trigger\EWARM\ADC_TIM_TRGO_Trigger.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\CRC\CRC_Calculation\EWARM\CRC_Calculation.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\DBG\DBG_TIM_Stop\EWARM\DBG_TIM_Stop.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\EXTI\EXTI_Interrupt\EWARM\EXTI_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\FLASH\FLASH_MainFlash_Erase_Program\EWARM\FLASH_MainFlash_Erase_Program.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\FLASH\FLASH_MainFlash_ReadProtection\EWARM\FLASH_MainFlash_ReadProtection.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\FLASH\FLASH_OptionByte_Erase_Program\EWARM\FLASH_OptionByte_Erase_Program.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\FLASH\FLASH_SimulateEEPROM\EWARM\FLASH_SimulateEEPROM.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\GPIO\GPIO_KEY_Input\EWARM\GPIO_KEY_Input.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\GPIO\GPIO_LED_Toggle\EWARM\GPIO_LED_Toggle.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\GPIO\GPIO_SWD_Remap\EWARM\GPIO_SWD_Remap.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\I2C\I2C_Master_EEPROM_Interrupt\EWARM\I2C_Master_EEPROM_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\I2C\I2C_Master_EEPROM_Polling\EWARM\I2C_Master_EEPROM_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\I2C\I2C_Master_Interrupt\EWARM\I2C_Master_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\I2C\I2C_Master_Polling\EWARM\I2C_Master_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\I2C\I2C_Master_SimulateWithGPIO\EWARM\I2C_Master_SimulateWithGPIO.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\I2C\I2C_Slave_Interrupt\EWARM\I2C_Slave_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\I2C\I2C_Slave_MultipleAddress\EWARM\I2C_Slave_MultipleAddress.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\I2C\I2C_Slave_Polling\EWARM\I2C_Slave_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\IWDG\IWDG_Interrupt\EWARM\IWDG_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\IWDG\IWDG_SystemMonitor\EWARM\IWDG_SystemMonitor.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\PWR\PWR_DeepStop_EXTI_Wakeup\EWARM\PWR_DeepStop_EXTI_Wakeup.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\PWR\PWR_DeepStop_IWDG_Wakeup\EWARM\PWR_DeepStop_IWDG_Wakeup.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\PWR\PWR_DeepStop_PVD_Wakeup\EWARM\PWR_DeepStop_PVD_Wakeup.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\PWR\PWR_PVD_Interrupt\EWARM\PWR_PVD_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\PWR\PWR_PVD_Polling\EWARM\PWR_PVD_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\PWR\PWR_Sleep_WFE_Wakeup\EWARM\PWR_Sleep_WFE_Wakeup.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\PWR\PWR_Sleep_WFI_Wakeup\EWARM\PWR_Sleep_WFI_Wakeup.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\PWR\PWR_Stop_EXTI_Wakeup\EWARM\PWR_Stop_EXTI_Wakeup.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\PWR\PWR_Stop_IWDG_Wakeup\EWARM\PWR_Stop_IWDG_Wakeup.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\PWR\PWR_Stop_PVD_Wakeup\EWARM\PWR_Stop_PVD_Wakeup.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RCC\RCC_GetResetReason\EWARM\RCC_GetResetReason.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\RCC\RCC_MCO\EWARM\RCC_MCO.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\SPI\SPI_Master_FLASH_Interrupt\EWARM\SPI_Master_FLASH_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\SPI\SPI_Master_FLASH_Polling\EWARM\SPI_Master_FLASH_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\SPI\SPI_Master_Interrupt\EWARM\SPI_Master_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\SPI\SPI_Master_Polling\EWARM\SPI_Master_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\SPI\SPI_Master_SimulateWithGPIO\EWARM\SPI_Master_SimulateWithGPIO.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\SPI\SPI_Slave_Interrupt\EWARM\SPI_Slave_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\SPI\SPI_Slave_Polling\EWARM\SPI_Slave_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\TIM1\TIM1_OnePulseOutput\EWARM\TIM1_OnePulseOutput.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\TIM1\TIM1_PWM_6StepOutput_DeadTime_Break\EWARM\TIM1_PWM_6StepOutput_DeadTime_Break.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\TIM1\TIM1_PWM_Output\EWARM\TIM1_PWM_Output.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\TIM1\TIM1_PWM_PhaseShift\EWARM\TIM1_PWM_PhaseShift.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\TIM1\TIM1_Synchronization\EWARM\TIM1_Synchronization.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\TIM1\TIM1_TimeBase\EWARM\TIM1_TimeBase.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\TIM14\TIM14_TimeBase\EWARM\TIM14_TimeBase.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\TIM3\TIM3_Encoder\EWARM\TIM3_Encoder.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\TIM3\TIM3_Hall\EWARM\TIM3_Hall.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\TIM3\TIM3_InputCapture\EWARM\TIM3_InputCapture.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\TIM3\TIM3_PWM_InputCapture\EWARM\TIM3_PWM_InputCapture.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\TIM3\TIM3_TimeBase\EWARM\TIM3_TimeBase.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\UID\UID_ReadUID\EWARM\UID_ReadUID.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\USART\USART_9BitDataCommunication\EWARM\USART_9BitDataCommunication.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\USART\USART_Interrupt\EWARM\USART_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\USART\USART_Polling\EWARM\USART_Polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\USART\USART_SimulateWithGPIO\EWARM\USART_SimulateWithGPIO.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\USART\USART_SingleWireHalfDuplexCommunication\EWARM\USART_SingleWireHalfDuplexCommunication.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\USART\USART_Synchronous_Interrupt\EWARM\USART_Synchronous_Interrupt.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\USART\USART_Synchronous_Polling\EWARM\USART_Synchronous_Polling.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>wk</name>
			<member>
				<project>ADC_AnalogWatchdog</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ADC_AnyChannel_ContinuousScan_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ADC_AnyChannel_ContinuousScan_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ADC_AnyChannel_OneCycleScan_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ADC_AnyChannel_OneCycleScan_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ADC_AnyChannel_SingleConversion_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ADC_AnyChannel_SingleConversion_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ADC_EXTI_Trigger</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ADC_InternalVoltageSensor</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ADC_TIM_CC_Trigger</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ADC_TIM_TRGO_Trigger</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>CRC_Calculation</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>DBG_TIM_Stop</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>EXTI_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>FLASH_MainFlash_Erase_Program</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>FLASH_MainFlash_ReadProtection</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>FLASH_OptionByte_Erase_Program</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>FLASH_SimulateEEPROM</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>GPIO_KEY_Input</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>GPIO_LED_Toggle</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>GPIO_SWD_Remap</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>I2C_Master_EEPROM_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>I2C_Master_EEPROM_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>I2C_Master_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>I2C_Master_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>I2C_Master_SimulateWithGPIO</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>I2C_Slave_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>I2C_Slave_MultipleAddress</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>I2C_Slave_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>IWDG_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>IWDG_SystemMonitor</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>PWR_DeepStop_EXTI_Wakeup</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>PWR_DeepStop_IWDG_Wakeup</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>PWR_DeepStop_PVD_Wakeup</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>PWR_PVD_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>PWR_PVD_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>PWR_Sleep_WFE_Wakeup</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>PWR_Sleep_WFI_Wakeup</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>PWR_Stop_EXTI_Wakeup</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>PWR_Stop_IWDG_Wakeup</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>PWR_Stop_PVD_Wakeup</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>RCC_GetResetReason</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>RCC_MCO</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>SPI_Master_FLASH_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>SPI_Master_FLASH_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>SPI_Master_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>SPI_Master_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>SPI_Master_SimulateWithGPIO</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>SPI_Slave_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>SPI_Slave_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM1_OnePulseOutput</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM1_PWM_6StepOutput_DeadTime_Break</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM1_PWM_Output</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM1_PWM_PhaseShift</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM1_Synchronization</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM1_TimeBase</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM14_TimeBase</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM3_Encoder</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM3_Hall</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM3_InputCapture</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM3_PWM_InputCapture</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>TIM3_TimeBase</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>UID_ReadUID</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>USART_9BitDataCommunication</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>USART_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>USART_Polling</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>USART_SimulateWithGPIO</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>USART_SingleWireHalfDuplexCommunication</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>USART_Synchronous_Interrupt</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>USART_Synchronous_Polling</project>
				<configuration>Debug</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>
